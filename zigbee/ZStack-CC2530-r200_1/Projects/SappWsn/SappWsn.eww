<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SappWsn.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>SappWsn</project>
        <configuration>DemoEB</configuration>
      </member>
      <member>
        <project>SappWsn</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>SappWsn</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>SappWsn</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


